## Kconfig
```kconfig
menu "Zephyr"
source "Kconfig.zephyr"
endmenu

module = VCU
module-str = VCU
source "subsys/logging/Kconfig.template.log_config"
```
